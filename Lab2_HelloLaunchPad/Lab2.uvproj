# Keil uVision project Lab2.uvproj, settings and files
target HelloLaunchPad (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: HelloLaunchPad
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup.s
  group Object code
    ./: texas.o
